EXTRA_OEMESON:append = " \
    -Drest=enabled \
    -Dredfish-dbus-log=enabled \
    "