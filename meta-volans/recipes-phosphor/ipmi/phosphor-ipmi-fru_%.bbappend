DEPENDS:append = " volans-yaml-config"

IPMI_FRU_YAML = "${STAGING_DIR_HOST}${datadir}/volans-yaml-config/ipmi-fru-read.yaml"
IPMI_FRU_PROP_YAML = "${STAGING_DIR_HOST}${datadir}/volans-yaml-config/ipmi-extra-properties.yaml"
