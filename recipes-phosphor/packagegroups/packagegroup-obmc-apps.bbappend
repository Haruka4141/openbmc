RDEPENDS:${PN}-extras:append = " webui-vue \
                                 ipmitool \
                                 htop "